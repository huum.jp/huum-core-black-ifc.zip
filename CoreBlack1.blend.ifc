Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: CoreBlack1.blend.ifc
Time: 2023-04-06T16:11:54+03:00
Written by: IfcOpenShell v0.7.0-476ab506d
Made in: BlenderBIM 0.0.230304
Authorization: Nobody

# IfcActuator (35)
PredefinedType: ELECTRICACTUATOR
Name
8 x 1
7 x 2
6 x 3
5 x 5
4 x 4
4 x 6
Part__Feature
